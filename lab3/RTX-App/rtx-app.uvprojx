# Keil uVision project rtx-app.uvprojx, settings and files
target RTX App SIM (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.1
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rtx-app-sim
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: ECE350_P3
  c include: ..\include;..\include\bsp\LPC1768;.\src\kernel
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x7000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group bsp
    ./src/bsp/LPC1768/: uart_polling.c uart_irq.c timer.c
  group kernel
    ./src/kernel/: HAL.c k_mem.c k_msg.c k_rtx_init.c k_task.c k_mem.h k_inc.h k_msg.h k_rtx.h k_rtx_init.h k_task.h bit_array.c bit_array.h free_list.c free_list.h helper.c helper.h tester.c tester.h ready_queue.c ready_queue.h mailbox.c mailbox.h
  group libu
    ./src/libu/: printf.c
  group built-in tasks
    ./src/tasks/: cdisp_task.c kcd_task.c null_task.c wall_clock_task.c
  group Lib
    ../AE-Lib/Objects/SIM/: ae-lib-sim.lib
    ../AE-Lib/Objects/RAM/: ae-lib-ram.lib
target RTX App RAM (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.1
  cpu: as above
  output: rtx-app-ram
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: ECE350_P3
  c include: ..\include;..\include\bsp\LPC1768;.\src\kernel
  asm define: NO_CRP
  memory RVCT4: ROM 0x10000000 size 0x4000
  memory RVCT9: RAM 0x10004000 size 0x3000
  memory RVCT10: RAM 0x2007c000 size 0x8000
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
